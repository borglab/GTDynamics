Commit message: add all the SDF/URDF files for the examples in the common directories

File: urdfs/inverted_pendulum.urdf (robot description, URDF)
Before this commit: robot cart_pole, 3 links, 2 joints
Links:
- removed link l0
Joints:
- removed joint j0
